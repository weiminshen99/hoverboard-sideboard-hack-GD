# IAR project GD32150C-START.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\class\device\hid\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\device\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_library\usbd\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Mouse.srec
  ILINK.IlinkOutputFile: HID_Keyboard.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F150x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f1x0_it.c gd32f1x0_usbd_hw.c hid_keyboard_itf.c main.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F150C_START
    ../../../Utilities/: gd32f150c_start.c
  group GD32F1x0_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USBD_Class
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group USBD_Device
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
