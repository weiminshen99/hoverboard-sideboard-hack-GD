# Keil uVision project Project.uvproj, settings and files
target GD32150R-EVAL (ARM-ADS)
  device: GD32F150R8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F130_150
  c include: ..\..\16_HDMI-CEC_HostSlaveCommunication;..\Soft_Drive;..\..\..\Utilities;..\..\..\..\GD32F1x0_Firmware_Library\CMSIS;..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32f1x0_it.c systick.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group GD32F1x0_EVAL
    ../../../Utilities/: gd32f150r_eval.c
  group Soft_Driver
    ../Soft_Drive/: gui.c lcd_driver.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Doc
    ../: readme.txt
